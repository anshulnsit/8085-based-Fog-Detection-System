	JMP LABEL0
# ORG 0050
LABEL0:	CALL LABEL1
	MVI A,24H
	OUT 80H
	MVI A,20H
	OUT 80H
	CALL LABEL2
	MVI A,24H
	OUT 80H
	MVI A,20H
	OUT 80H
	CALL LABEL3
	MVI A,84H
	OUT 80H
	MVI A,80H
	OUT 80H
	MVI A,04H
	OUT 80H
	MVI A,00H
	OUT 80H
	MVI A,E4H
	OUT 80H
	MVI A,E0H
	OUT 80H
	MVI A,04H
	OUT 80H
	MVI A,00H
	OUT 80H
	MVI A,64H
	OUT 80H
	MVI A,60H
	OUT 80H
	MVI A,4CH
	OUT 80H
	MVI A,48H
	OUT 80H
	MVI A,8CH
	OUT 80H
	MVI A,88H
	OUT 80H
	HLT
LABEL1:	LXI B,4E2H
LABEL4:	DCX B
	MOV A,B
	ORA C
	JNZ LABEL4
	RET
LABEL2:	LXI B,155H
LABEL5:	DCX B
	MOV A,B
	ORA C
	JNZ LABEL5
	RET
LABEL3:	MVI A,8H
LABEL6:	DCR A
	JNZ LABEL6
	RET
