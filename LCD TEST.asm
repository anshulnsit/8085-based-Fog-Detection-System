	JMP LABEL0
# ORG 0050
LABEL0:	CALL LABEL1
	MVI A,24H
	OUT 24H
	CALL LABEL2
	MVI A,24H
	OUT 24H
	CALL LABEL3
	MVI A,84H
	OUT 84H
	MVI A,04H
	OUT 04H
	MVI A,E4H
	OUT E4H
	MVI A,04H
	OUT 04H
	MVI A,64H
	OUT 64H
	MVI A,4CH
	OUT 4CH
	MVI A,8CH
	OUT 8CH
	HLT
LABEL1:	LXI B,593H
LABEL4:	DCX B
	MOV A,B
	ORA C
	JNZ LABEL4
	RET
LABEL2:	LXI B,1DBH
LABEL5:	DCX B
	MOV A,B
	ORA C
	JNZ LABEL5
	RET
LABEL3:	MVI A,FH
LABEL6:	DCR A
	JNZ LABEL6
	RET
